# Keil uVision project mbed_stm32f10x_src.uvproj, settings and files
target mbed NUCLEO_F103RB (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: mbed_stm32f10x_src
  AfterMake: fromelf --bin -o build\mbed_stm32f10x_src_NUCLEO_F103RB.bin build\mbed_stm32f10x_src.axf
  c flags: Optim=2
  c define: TARGET_NUCLEO_F103RB,  TARGET_M3,  TARGET_CORTEX_M,  TARGET_STM,  TARGET_STM32F1,  TARGET_STM32F103RB,  TOOLCHAIN_ARM_MICRO,  TOOLCHAIN_ARM,  __CORTEX_M3,  ARM_MATH_CM3,  MBED_BUILD_TIMESTAMP=1429167707.34,  __MBED__=1,  TARGET_FF_ARDUINO,  TARGET_FF_MORPHO,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;mbed-rtos;mbed-rtos/rtos;mbed-rtos/rtx;mbed-rtos/rtx/TARGET_CORTEX_M;mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M3;mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M3/TOOLCHAIN_ARM;mbed-src;mbed-src/common;mbed-src/hal;mbed-src/api;mbed-src/targets;mbed-src/targets/cmsis;mbed-src/targets/cmsis/TARGET_STM;mbed-src/targets/cmsis/TARGET_STM/TARGET_STM32F1;mbed-src/targets/cmsis/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB;mbed-src/targets/cmsis/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/TOOLCHAIN_ARM_MICRO;mbed-src/targets/hal;mbed-src/targets/hal/TARGET_STM;mbed-src/targets/hal/TARGET_STM/TARGET_STM32F1;mbed-src/targets/hal/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB;.\user-tasks;.\user-modules;.\user-common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: mbed-src/targets/cmsis/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/TOOLCHAIN_ARM_MICRO/stm32f103xb.sct
  group user-modules
    ./user-modules/: MsgBroker.h MsgBroker.cpp List.h List_tpp.h
  group user-tasks
    ./user-tasks/: GpsReader.cpp KeyDecoder.cpp SysManager.cpp BeepGenerator.cpp VirtualReceiver.cpp LedFlasher.cpp
  group user-main
    ./: main.cpp
  group user-common
    mbed-src/common/: retarget.cpp semihost_api.c
    ./user-common/: Topics.h
  group mbed-api
    ./mbed-src/api/: mbed.h mbed_assert.h mbed_debug.h
    ./mbed-src/targets/hal/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/: PinNames.h PortNames.h PeripheralNames.h
    mbed-src/common/: BusIn.cpp BusInOut.cpp BusOut.cpp CallChain.cpp CAN.cpp Ethernet.cpp FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp FunctionPointer.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp RawSerial.cpp Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp Stream.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp
  group mbed-lib
    mbed-src/targets/hal/TARGET_STM/TARGET_STM32F1/: analogin_api.c gpio_api.c gpio_irq_api.c i2c_api.c mbed_overrides.c pinmap.c port_api.c pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c us_ticker.c
    mbed-src/common/: assert.c board.c error.c gpio.c mbed_interface.c pinmap_common.c rtc_time.c us_ticker_api.c wait_api.c
    mbed-src/targets/hal/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/: PeripheralPins.c
  group cmsis-rtos-api
    ./mbed-rtos/rtos/: rtos.h
    mbed-rtos/rtos/: Mutex.cpp RtosTimer.cpp Semaphore.cpp Thread.cpp
  group cmsis-rtos-rtx
    ./mbed-rtos/rtx/TARGET_CORTEX_M/: cmsis_os.h
    mbed-rtos/rtx/TARGET_CORTEX_M/: RTX_Conf_CM.c HAL_CM.c rt_Event.c rt_CMSIS.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c
    mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M3/TOOLCHAIN_ARM/: HAL_CM3.c SVC_Table.s
  group cmsis-core-standard
    mbed-src/targets/cmsis/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/: cmsis_nvic.c hal_tick.c
  group cmsis-core-hal
    ./mbed-src/targets/cmsis/TARGET_STM/TARGET_STM32F1/: stm32f1xx_hal_conf.h
    mbed-src/targets/cmsis/TARGET_STM/TARGET_STM32F1/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
  group cmsis-core-device
    ./mbed-src/targets/cmsis/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/: stm32f1xx.h stm32f103xb.h
    mbed-src/targets/cmsis/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/TOOLCHAIN_ARM_MICRO/: startup_stm32f103xb.s sys.cpp
    mbed-src/targets/cmsis/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/: system_stm32f1xx.c
target STM32F103C8 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: mbed_stm32f10x_src
  AfterMake: as above
  c flags: Optim=1
  c define: PROCESADOR_STM32F103C8 TARGET_NUCLEO_F103RB,  TARGET_M3,  TARGET_CORTEX_M,  TARGET_STM,  TARGET_STM32F1,  TARGET_STM32F103RB,  TOOLCHAIN_ARM_MICRO,  TOOLCHAIN_ARM,  __CORTEX_M3,  ARM_MATH_CM3,  MBED_BUILD_TIMESTAMP=1429167707.34,  __MBED__=1,  TARGET_FF_ARDUINO,  TARGET_FF_MORPHO,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: mbed-src/targets/cmsis/TARGET_STM/TARGET_STM32F1/TARGET_NUCLEO_F103RB/TOOLCHAIN_ARM_MICRO/stm32f103c8.sct
